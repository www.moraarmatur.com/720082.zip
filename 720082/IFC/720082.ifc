Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Users\Jonas\Documents\Cadfocus\Ostnor\Projekt\20140212_CAD-objekt_Göran_prio2\ARBETSMAPP\720082\AutoCAD Architecture\720082.ifc
Time: 2014-03-04T12:32:21
Author: - -
Organization: Ostnor AB
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 720082
LongName: 720082
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 720082
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 720082, BUILDINGELEMENTPROXY(1)
In: 720082
Description: Mora Armatur 720082, MMIX Tronic washbasin mixer, chrome
